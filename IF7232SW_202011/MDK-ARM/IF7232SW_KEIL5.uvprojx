# Keil uVision project IF7232SW_KEIL5.uvprojx, settings and files
target IF7232SW_KEIL5 (ARM-ADS)
  device: STM32G070RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: IF7232SW_KEIL5 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G070xx,USE_HAL_DRIVER,STM32G070xx
  c include: ../Inc;                                          ../Drivers/STM32G0xx_HAL_Driver/Inc;                                          ../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;                                          ../Drivers/CMSIS/Device/ST/STM32G0xx/Include;                                          ..\SM1616;                                          ..\APT8L16;                                          ..\NTC;                                          ..\PowerDeal;                                          ..\flash;                                          ..\wifi;                                          ..\malloc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g070xx.s
  group APT8L16
    ../APT8L16/: apt8l16_12_dev.c apt8l16_12_drv.c apt8l16_3_dev.c apt8l16_3_drv.c key.c
  group SM1616
    ../SM1616/: sm1616_drv.c sm1616_dev.c display.c
  group Application/User
    ../Src/: main.c gpio.c tim.c usart.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
  group NTC
    ../NTC/: ntc.c
  group PowerManage
    ../PowerDeal/: power_level_manage.c
    ../flash/: embedded_flash.c
  group WIFI
    ../wifi/: bsp_esp32.c iot.c
    ../malloc/: malloc.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_gpio.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c
software components: CMSIS:CORE 4.3.0
